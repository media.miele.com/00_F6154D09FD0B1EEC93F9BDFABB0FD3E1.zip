Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2021-11-24T13:41:33
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Nov 24 13:41:33 2021 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\{00AB3F1C-E181-4007-A3DF-6E5240F2CB7F}\ifc * Database version: 5507 * Database creation date: Wed Nov 24 13:41:32 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Nov 24 13:41:32 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Nov 24 13:41:32 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 22767046_USA_11804610_H7670BM_EDST-CLST, 11804610_USA_H7670BM_EDST-CLST:22767046_USA_11804610_H7670BM_EDST-CLST:206801
In: Level 1
Type - Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_CLST, z_Miele_Design_OBSW, z_Miele_Design_Glass Black, z_Miele_Design_Zinc_Steel, z_Miele_Connection_Electric
Pset_BuildingElementProxyCommon - Reference: 22767046_USA_11804610_H7670BM_EDST-CLST
Pset_ManufacturerTypeInformation - Manufacturer: Miele
